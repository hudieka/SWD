<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\Source\App\main.c</name>
    </file>
  </group>
  <group>
    <name>Drv</name>
    <file>
      <name>$PROJ_DIR$\..\Source\Drv\uart\MKL_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Drv\uart\retarget_iar.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\CMSIS\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Common\startup_MKL25Z4_iar.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Common\system_MKL25Z4.c</name>
    </file>
  </group>
  <group>
    <name>SWD</name>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\DAP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\dap_vendor_command.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\debug_cm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\SW_DP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\swd_host.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SWD\target_reset.c</name>
    </file>
  </group>
</project>


