# IAR project Kinetis_L_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\Source\App; ..\Source\Drv\gpio; ..\Source\Drv\uart; ..\..\..\..\CMSIS; ..\..\..\..\Common; ..\..\..\..\Headers; ..\Source\SWD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Kinetis_L_Demo.srec
  ILINK.IlinkOutputFile: Kinetis_L_Demo.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../Source/App/: main.c
  group Drv
    ../Source/Drv/uart/: MKL_uart.c retarget_iar.c
  group Startup
    ../../../../CMSIS/: arm_cm0.c
    ../../../../Common/: startup_MKL25Z4_iar.s system_MKL25Z4.c
  group SWD
    ../Source/SWD/: DAP.c dap_vendor_command.c debug_cm.c SW_DP.c swd_host.c target_reset.c
